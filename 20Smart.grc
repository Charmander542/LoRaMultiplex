options:
  parameters:
    generate_options: qt_gui
    id: SmartMultiplexer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: atten
  id: variable
  parameters:
    value: '80'
  states: {}
- name: ch_bw
  id: variable
  parameters:
    value: ch_rate/2
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: ch_tb
  id: variable
  parameters:
    value: 20e3
  states: {}
- name: channels
  id: variable
  parameters:
    value: '20'
  states: {}
- name: delay_samples
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: meshtastic_us_channels
  id: variable
  parameters:
    value: '[906875000, 907075000, 907275000, 907475000, 907675000, 907875000, 908075000, 908275000, 908475000, 908675000, 908875000, 909075000, 909275000, 909475000, 909675000, 909875000, 910075000, 910275000, 910475000, 910675000, 910875000, 911075000, 911275000, 911475000, 911675000, 911875000, 912075000, 912275000, 912475000, 912675000, 912875000, 913075000, 913275000, 913475000, 913675000, 913875000, 914075000, 914275000, 914475000, 914675000, 914875000]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: ch_rate*channels
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass_2(1, samp_rate, ch_bw, ch_tb, atten)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '20'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_3_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_4
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_1_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_2_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_3_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_4_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_5
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_5_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_6
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_6_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_7
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_7_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_8
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_8_0
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_9
  id: blocks_delay
  parameters:
    delay: delay_samples
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: channels
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """
          Gated Router Block:
          - Passes data for channels that cross a power threshold.
          - Includes a message port to output the set of active channels on change.
          - Keeps channels open for a configurable duration after power drops.
          """
          def __init__(self, num_channels=20, threshold_db=-40.0, hold_time_s=2.0, samp_rate=1e6):
              self.threshold = 10**(threshold_db/10.0)
              self.num_channels = num_channels
              self.samp_rate = samp_rate
              # Calculate the number of samples to hold the channel open
              self.hold_samples = int(hold_time_s * self.samp_rate)

              in_sigs = [np.complex64] * self.num_channels
              in_sigs.append((np.float32, self.num_channels))
              out_sigs = [np.complex64] * self.num_channels

              gr.sync_block.__init__(
                  self,
                  name="Gated Router",
                  in_sig=in_sigs,
                  out_sig=out_sigs,
              )
              # State to track which channels are currently active
              self.active_channels = [False] * self.num_channels
              # State to remember the previous state for change detection
              self.last_active_state = list(self.active_channels)
              # Hold counters for each channel
              self.hold_counters = [0] * self.num_channels

              # Register the new message port for debugging
              self.message_port_register_out(pmt.intern("active_channels_debug"))

          def work(self, input_items, output_items):
              power_vector_buffer = input_items[self.num_channels]
              num_to_process = len(output_items[0])

              if len(power_vector_buffer) > 0:
                  power_vector = power_vector_buffer[0]
                  for i in range(self.num_channels):
                      if power_vector[i] > self.threshold:
                          self.active_channels[i] = True
                          self.hold_counters[i] = self.hold_samples
                      elif self.hold_counters[i] > 0:
                          self.active_channels[i] = True
                          self.hold_counters[i] -= num_to_process
                          if self.hold_counters[i] < 0:
                              self.hold_counters[i] = 0
                      else:
                          self.active_channels[i] = False
              else:
                  # If there's no new power vector, maintain the state based on hold counters
                  for i in range(self.num_channels):
                      if self.hold_counters[i] > 0:
                          self.active_channels[i] = True
                          self.hold_counters[i] -= num_to_process
                          if self.hold_counters[i] < 0:
                              self.hold_counters[i] = 0
                      else:
                          self.active_channels[i] = False

              # Check if the state of active channels has changed
              if self.active_channels != self.last_active_state:
                  active_indices = [i for i, status in enumerate(self.active_channels) if status]
                  debug_str = f"Active: {active_indices}"
                  msg = pmt.to_pmt(debug_str)
                  self.message_port_pub(pmt.intern("active_channels_debug"), msg)
                  self.last_active_state = list(self.active_channels)

              for i in range(self.num_channels):
                  if self.active_channels[i]:
                      output_items[i][:num_to_process] = input_items[i][:num_to_process]
                  else:
                      output_items[i][:num_to_process] = 0

              # In a sync_block, we return the number of items produced on each output stream.
              # The scheduler handles consuming the corresponding number of input items.
              # The explicit consume calls from the original code were incorrect for a sync_block.
              return num_to_process
    hold_time_s: '1'
    num_channels: channels
    samp_rate: ch_rate
    threshold_db: '-60'
  states: {}
- name: lora_rx_0_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: '250000'
    sf: '7'
    soft_decoding: 'False'
    sync_word: '[0x34]'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '80'
    ch_map: '[]'
    nchans: channels
    osr: '1.0'
    taps: taps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/channels
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 910.3e6
    dev_addr: '"serial: 3134BCA"'
    gain0: '20'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', lora_rx_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_streams_to_vector_0, '4']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_streams_to_vector_0, '5']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_streams_to_vector_0, '11']
- [blocks_complex_to_mag_squared_0_0_1, '0', blocks_streams_to_vector_0, '15']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_streams_to_vector_0, '6']
- [blocks_complex_to_mag_squared_0_1_0, '0', blocks_streams_to_vector_0, '2']
- [blocks_complex_to_mag_squared_0_1_0_0, '0', blocks_streams_to_vector_0, '12']
- [blocks_complex_to_mag_squared_0_1_1, '0', blocks_streams_to_vector_0, '8']
- [blocks_complex_to_mag_squared_0_1_1_0, '0', blocks_streams_to_vector_0, '18']
- [blocks_complex_to_mag_squared_0_1_2, '0', blocks_streams_to_vector_0, '16']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_streams_to_vector_0, '7']
- [blocks_complex_to_mag_squared_0_2_0, '0', blocks_streams_to_vector_0, '3']
- [blocks_complex_to_mag_squared_0_2_0_0, '0', blocks_streams_to_vector_0, '13']
- [blocks_complex_to_mag_squared_0_2_1, '0', blocks_streams_to_vector_0, '9']
- [blocks_complex_to_mag_squared_0_2_1_0, '0', blocks_streams_to_vector_0, '19']
- [blocks_complex_to_mag_squared_0_2_2, '0', blocks_streams_to_vector_0, '17']
- [blocks_complex_to_mag_squared_0_3, '0', blocks_streams_to_vector_0, '0']
- [blocks_complex_to_mag_squared_0_3_0, '0', blocks_streams_to_vector_0, '10']
- [blocks_complex_to_mag_squared_0_4, '0', blocks_streams_to_vector_0, '14']
- [blocks_delay_0, '0', epy_block_0, '0']
- [blocks_delay_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_delay_0_0, '0', epy_block_0, '1']
- [blocks_delay_0_0_0, '0', epy_block_0, '11']
- [blocks_delay_0_1, '0', epy_block_0, '2']
- [blocks_delay_0_1_0, '0', epy_block_0, '12']
- [blocks_delay_0_2, '0', epy_block_0, '3']
- [blocks_delay_0_2_0, '0', epy_block_0, '13']
- [blocks_delay_0_3, '0', epy_block_0, '4']
- [blocks_delay_0_3_0, '0', epy_block_0, '14']
- [blocks_delay_0_4, '0', epy_block_0, '5']
- [blocks_delay_0_4_0, '0', epy_block_0, '15']
- [blocks_delay_0_5, '0', epy_block_0, '6']
- [blocks_delay_0_5_0, '0', epy_block_0, '16']
- [blocks_delay_0_6, '0', epy_block_0, '7']
- [blocks_delay_0_6_0, '0', epy_block_0, '17']
- [blocks_delay_0_7, '0', epy_block_0, '8']
- [blocks_delay_0_7_0, '0', epy_block_0, '18']
- [blocks_delay_0_8, '0', epy_block_0, '9']
- [blocks_delay_0_8_0, '0', epy_block_0, '19']
- [blocks_delay_0_9, '0', epy_block_0, '10']
- [blocks_streams_to_vector_0, '0', epy_block_0, '20']
- [epy_block_0, '0', blocks_add_xx_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '1', blocks_add_xx_0, '1']
- [epy_block_0, '10', blocks_add_xx_0, '10']
- [epy_block_0, '11', blocks_add_xx_0, '11']
- [epy_block_0, '12', blocks_add_xx_0, '12']
- [epy_block_0, '13', blocks_add_xx_0, '13']
- [epy_block_0, '14', blocks_add_xx_0, '14']
- [epy_block_0, '15', blocks_add_xx_0, '15']
- [epy_block_0, '16', blocks_add_xx_0, '16']
- [epy_block_0, '17', blocks_add_xx_0, '17']
- [epy_block_0, '18', blocks_add_xx_0, '18']
- [epy_block_0, '19', blocks_add_xx_0, '19']
- [epy_block_0, '2', blocks_add_xx_0, '2']
- [epy_block_0, '3', blocks_add_xx_0, '3']
- [epy_block_0, '4', blocks_add_xx_0, '4']
- [epy_block_0, '5', blocks_add_xx_0, '5']
- [epy_block_0, '6', blocks_add_xx_0, '6']
- [epy_block_0, '7', blocks_add_xx_0, '7']
- [epy_block_0, '8', blocks_add_xx_0, '8']
- [epy_block_0, '9', blocks_add_xx_0, '9']
- [epy_block_0, active_channels_debug, blocks_message_debug_0, print]
- [pfb_channelizer_ccf_0, '0', blocks_complex_to_mag_squared_0_3, '0']
- [pfb_channelizer_ccf_0, '0', blocks_delay_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_complex_to_mag_squared_0_0_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_delay_0_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_complex_to_mag_squared_0_3_0, '0']
- [pfb_channelizer_ccf_0, '10', blocks_delay_0_9, '0']
- [pfb_channelizer_ccf_0, '11', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '11', blocks_delay_0_0_0, '0']
- [pfb_channelizer_ccf_0, '12', blocks_complex_to_mag_squared_0_1_0_0, '0']
- [pfb_channelizer_ccf_0, '12', blocks_delay_0_1_0, '0']
- [pfb_channelizer_ccf_0, '13', blocks_complex_to_mag_squared_0_2_0_0, '0']
- [pfb_channelizer_ccf_0, '13', blocks_delay_0_2_0, '0']
- [pfb_channelizer_ccf_0, '14', blocks_complex_to_mag_squared_0_4, '0']
- [pfb_channelizer_ccf_0, '14', blocks_delay_0_3_0, '0']
- [pfb_channelizer_ccf_0, '15', blocks_complex_to_mag_squared_0_0_1, '0']
- [pfb_channelizer_ccf_0, '15', blocks_delay_0_4_0, '0']
- [pfb_channelizer_ccf_0, '16', blocks_complex_to_mag_squared_0_1_2, '0']
- [pfb_channelizer_ccf_0, '16', blocks_delay_0_5_0, '0']
- [pfb_channelizer_ccf_0, '17', blocks_complex_to_mag_squared_0_2_2, '0']
- [pfb_channelizer_ccf_0, '17', blocks_delay_0_6_0, '0']
- [pfb_channelizer_ccf_0, '18', blocks_complex_to_mag_squared_0_1_1_0, '0']
- [pfb_channelizer_ccf_0, '18', blocks_delay_0_7_0, '0']
- [pfb_channelizer_ccf_0, '19', blocks_complex_to_mag_squared_0_2_1_0, '0']
- [pfb_channelizer_ccf_0, '19', blocks_delay_0_8_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_complex_to_mag_squared_0_1_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_delay_0_1, '0']
- [pfb_channelizer_ccf_0, '3', blocks_complex_to_mag_squared_0_2_0, '0']
- [pfb_channelizer_ccf_0, '3', blocks_delay_0_2, '0']
- [pfb_channelizer_ccf_0, '4', blocks_complex_to_mag_squared_0, '0']
- [pfb_channelizer_ccf_0, '4', blocks_delay_0_3, '0']
- [pfb_channelizer_ccf_0, '5', blocks_complex_to_mag_squared_0_0, '0']
- [pfb_channelizer_ccf_0, '5', blocks_delay_0_4, '0']
- [pfb_channelizer_ccf_0, '6', blocks_complex_to_mag_squared_0_1, '0']
- [pfb_channelizer_ccf_0, '6', blocks_delay_0_5, '0']
- [pfb_channelizer_ccf_0, '7', blocks_complex_to_mag_squared_0_2, '0']
- [pfb_channelizer_ccf_0, '7', blocks_delay_0_6, '0']
- [pfb_channelizer_ccf_0, '8', blocks_complex_to_mag_squared_0_1_1, '0']
- [pfb_channelizer_ccf_0, '8', blocks_delay_0_7, '0']
- [pfb_channelizer_ccf_0, '9', blocks_complex_to_mag_squared_0_2_1, '0']
- [pfb_channelizer_ccf_0, '9', blocks_delay_0_8, '0']
- [uhd_usrp_source_0, '0', pfb_channelizer_ccf_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
