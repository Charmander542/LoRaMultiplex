<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_receive_realtime</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bitrate</value></param>
<param><key>value</key><value>sf * (1 / (2**sf / float(bw)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>capture_freq</value></param>
<param><key>value</key><value>908.6e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>bw/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>comment</key><value>The decimation determines the oversampling rate.
A sample rate of 1e6 and decimation of 1 equals
8 times oversampling, a decimation of 2 is 4 times
oversampling, and so on. Set higher decimation
for better performance, but worse accuracy.</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>downlink</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_tap</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, bw, 10000, firdes.WIN_HAMMING, 6.67)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>30e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate0</value></param>
<param><key>value</key><value>500e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbols_per_sec</value></param>
<param><key>value</key><value>float(bw) / (2**sf)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>target_freq</value></param>
<param><key>value</key><value>908.6e6</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>capture_freq</value></param>
<param><key>channel_list</key><value>[target_freq]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>downlink</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>7</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>capture_freq</value></param>
<param><key>channel_list</key><value>[target_freq]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>downlink</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>8</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_0_0</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>capture_freq</value></param>
<param><key>channel_list</key><value>[target_freq]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>downlink</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>9</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_0_1</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>capture_freq</value></param>
<param><key>channel_list</key><value>[target_freq]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>downlink</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>10</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_0_2</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>capture_freq</value></param>
<param><key>channel_list</key><value>[target_freq]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>downlink</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>sf</value></param>
</block>
<block>
<key>lora_lora_receiver</key>
<param><key>id</key><value>lora_lora_receiver_0_0_3</value></param>
<param><key>bandwidth</key><value>bw</value></param>
<param><key>crc</key><value>True</value></param>
<param><key>center_freq</key><value>capture_freq</value></param>
<param><key>channel_list</key><value>[target_freq]</value></param>
<param><key>cr</key><value>4</value></param>
<param><key>conj</key><value>downlink</value></param>
<param><key>decimation</key><value>decimation</value></param>
<param><key>disable_channelization</key><value>False</value></param>
<param><key>disable_drift_correction</key><value>False</value></param>
<param><key>implicit</key><value>False</value></param>
<param><key>reduced_rate</key><value>False</value></param>
<param><key>samp_rate</key><value>1e6</value></param>
<param><key>sf</key><value>12</value></param>
</block>
<block>
<key>lora_message_socket_sink</key>
<param><key>id</key><value>lora_message_socket_sink_0</value></param>
<param><key>ip</key><value>127.0.0.1</value></param>
<param><key>layer</key><value>0</value></param>
<param><key>port</key><value>40868</value></param>
</block>
<block>
<key>meshtastic16</key>
<param><key>id</key><value>meshtastic16_0</value></param>
<param><key>center_freq</key><value>-4700e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<block>
<key>meshtastic16</key>
<param><key>id</key><value>meshtastic16_0_0</value></param>
<param><key>center_freq</key><value>-1500e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<block>
<key>meshtastic16</key>
<param><key>id</key><value>meshtastic16_0_1</value></param>
<param><key>center_freq</key><value>1700e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<block>
<key>meshtastic16</key>
<param><key>id</key><value>meshtastic16_0_1_0</value></param>
<param><key>center_freq</key><value>4900e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>capture_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>target_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>lora_lora_receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>lora_lora_receiver_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>lora_lora_receiver_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>lora_lora_receiver_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>lora_lora_receiver_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>lora_lora_receiver_0_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_0_0</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_0_1</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_0_2</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lora_lora_receiver_0_0_3</source_block_id><sink_block_id>lora_message_socket_sink_0</sink_block_id><source_key>frames</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>meshtastic16_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>meshtastic16_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>meshtastic16_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>meshtastic16_0_1_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>meshtastic16_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>meshtastic16_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>meshtastic16_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>meshtastic16_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
