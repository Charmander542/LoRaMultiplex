<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lora_receive_realtime_64ch</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>comment</key><value>This flowgraph has been edited to monitor 64 channels simultaneously.
This is EXTREMELY CPU-INTENSIVE and may not run in real-time.</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>64-Channel LoRa Monitor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bitrate</value></param>
<param><key>value</key><value>sf * (1 / (2**sf / float(bw)))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>125000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>capture_freq</value></param>
<param><key>comment</key><value>Center of the 902-928MHz ISM band</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff</value></param>
<param><key>value</key><value>bw/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>downlink</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>firdes_tap</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, bw, 10000, firdes.WIN_HAMMING, 6.67)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>comment</key><value>Increased to cover a wider part of the band.
28e6 would be needed for the full band.</value></param>
<param><key>value</key><value>16e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate0</value></param>
<param><key>comment</key><value>This should ideally match the main samp_rate for the recenter to work correctly.</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sf</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>64</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>"TX/RX"</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>capture_freq</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_1</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>capture_freq</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>recenter</key>
<param><key>id</key><value>recenter_gen_0</value></param>
<param><key>htd_offset</key><value>(0 - 31.5) * 200e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<block>
<key>recenter</key>
<param><key>id</key><value>recenter_gen_1</value></param>
<param><key>htd_offset</key><value>(1 - 31.5) * 200e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<block>
<key>recenter</key>
<param><key>id</key><value>recenter_gen_62</value></param>
<param><key>htd_offset</key><value>(62 - 31.5) * 200e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<block>
<key>recenter</key>
<param><key>id</key><value>recenter_gen_63</value></param>
<param><key>htd_offset</key><value>(63 - 31.5) * 200e3</value></param>
<param><key>cutoff</key><value>cutoff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate0</key><value>samp_rate0</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>recenter_gen_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>recenter_gen_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>recenter_gen_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>recenter_gen_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>recenter_gen_62</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>recenter_gen_62</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>62</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>recenter_gen_63</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>recenter_gen_63</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>63</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
